# Keil uVision project uCOS+LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS-III +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\APP;..\BSP;..\CMSIS;..\FWlib\inc;..\USER;..\uCOS-III\Cfg;..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR;..\uCOS-III\Source;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\Sensor;..\BSP\STM32_CPAL_Driver\inc;..\BSP\STM32_CPAL_Driver\devices\stm32f10x;..\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group APP
    ../APP/: global.h global.c app.c app_cfg.h os_app_hooks.c os_cfg_app.h os_cfg.h SerPrintTask.c FreqGetTask.c ADSampleTask.c OscTask.c MenuTask.c GeneratorTask.c GetKeyTask.c DCTask.c AutoTuneTask.c
    ../uCOS-III/uC-CPU/: cpu_cfg.h
  group USER
    ../USER/: stm32f10x_conf.h includes.h stm32f10x_it.c isr_cfg.h eeprom.c eeprom.h algorithm.c algorithm.h
  group Modules
    ../Modules/: mini12864.h mini12864.c GUI.h GUI.c genetic.h genetic.c
  group STM32_CPAL_Driver
    ../BSP/STM32_CPAL_Driver/inc/: cpal.h cpal_i2c.h cpal_conf.h
    ../BSP/STM32_CPAL_Driver/src/: cpal_i2c.c cpal_hal.c
    ../BSP/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c cpal_i2c_hal_stm32f10x.h
    ../BSP/STM32_CPAL_Driver/: cpal_usercallback.c
  group BSP
    ../BSP/: BSP.c BSP.h bsp_int.c bsp_periph.c bsp_ser.c bsp_ser.h bsp_os.c bsp_i2c.c bsp_i2c.h bsp_pwm.c bsp_pwm.h bsp_adc.c bsp_adc.h bsp_spi.c bsp_spi.h bsp_tim2.h bsp_tim2.c bsp_exti_PA11.c bsp_exti_PA11.h bsp_encoder.h bsp_encoder.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC\Source
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h
  group uC\Ports
    ../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group uC\LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC\CPU
    ../uCOS-III/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c cpu.h cpu_core.h cpu_def.h
